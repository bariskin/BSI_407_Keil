# Keil uVision project BSI_407.uvprojx, settings and files
target BSI_407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BSI_407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FreeModbusSlave/include;../FreeModbusSlave/app;../FreeModbusSlave/port;../FreeModbusSlave/rtu;../ModbusSetting/Inc;../HoldingRegisterSlave/Inc;../FreeModbusMaster/include/mb_m;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../ModBusAddrConverter/Inc;../bsp/Inc;../FreeModbusMaster/user_mb_app;../UARTSlaveSettings/Inc;../FlashDriver/Inc;../DisplayDriver/Inc;../RingBuffer/Inc;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../SdDriver/Inc;../SensorLogs/Inc;../RelayModule/Inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c i2c.c gpio.c rtc.c sdio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Core/Src/: freertos.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../FreeModbusSlave/: mb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeModbusSlave
    ../FreeModbusSlave/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbusSlave/app/: user_mb_app.c user_mb_app.h
    ../FreeModbusSlave/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbproto.h mbutils.h
    ../FreeModbusSlave/port/: port.h portcritical.c portcritical.h portevent.c portserial.c porttimer.c
    ../FreeModbusSlave/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group ModbusSetting
    ../ModbusSetting/Src/: ModbusSettings.c
  group FreeModbusMaster
    ../FreeModbusMaster/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../FreeModbusMaster/port/: portevent_m.c portserial_m.c porttimer_m.c
    ../FreeModbusMaster/rtu/: mbrtu_m.c
    ../FreeModbusMaster/: mb_m.c
    ../FreeModbusMaster/user_mb_app/: user_mb_app_m.c
    ../ModBusAddrConverter/Src/: ModBusAddrConverter.c
  group HoldingRegisterSlave
    ../HoldingRegisterSlave/Src/: HoldingRegisterSlaveHandler.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group bsp
    ../bsp/Src/: bsp.c
  group UARTSlaveSetting
    ../UARTSlaveSettings/Src/: UARTSlaveSettings.c
  group FlashDriver
    ../FlashDriver/Src/: FlashDriver.c
  group DisplayDriver
    ../DisplayDriver/Src/: DisplayDriver.c
  group RingBuffer
    ../RingBuffer/Src/: RingBuffer.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group SensorLogs
    ../SensorLogs/Src/: SensorLogs.c
  group ReleyModule
    ../RelayModule/Src/: RelayModule.c
software components: CMSIS:CORE 5.5.0
